# Keil uVision project GPS_PJ.uvprojx, settings and files
target Source Code (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPS_PJ +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\source\libs\CMSIS\CM3\CoreSupport;..\source\libs\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\source\libs\STM32F10x_StdPeriph_Driver\inc;..\source\app\delay\inc;..\source\app\template;..\source\app\gps\inc;..\source\app\lcd16x2\inc;..\source\app\main\inc;..\source\app\queue\inc;..\source\app\systick\inc;..\source\app\usart\inc;..\source\app\external;..\source\app\gpio\inc;..\source\app\dataParser\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Libs
    ../source/libs/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../source/libs/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../source/libs/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c
  group App
    ../source/app/delay/src/: delay.c
    ../source/app/external/: stm32f10x_it.c system_stm32f10x.c
    ../source/app/gps/src/: gps.c
    ../source/app/lcd16x2/src/: lcd16x2.c
    ../source/app/main/src/: main.c
    ../source/app/queue/src/: queue.c
    ../source/app/usart/src/: usart.c
    ../source/app/gpio/src/: gpio.c
    ../source/app/systick/src/: systick.c
    ../source/app/dataParser/src/: dataParser.c
